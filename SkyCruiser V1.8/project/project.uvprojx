# Keil uVision project project.uvprojx, settings and files
target SkyCruiser (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103ZE
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\lib\mcu_lib\cm3_lib\DeviceSupport\ST\STM32F10x;..\lib\mcu_lib\cm3_lib\CoreSupport;..\lib\mcu_lib\stf103_lib\inc;..\lib\driver_lib;..\lib\driver_lib\iic;..\lib\driver_lib\mpu6050;..\lib\driver_lib\mpu6050\eMPL;..\app;..\app\algorithm;..\app\protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group lib
    ../lib/mcu_lib/cm3_lib/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../lib/mcu_lib/cm3_lib/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h
    ../lib/mcu_lib/cm3_lib/CoreSupport/: core_cm3.c
    ../lib/mcu_lib/stf103_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group algorithm
    ../app/algorithm/: my_math.c my_math.h filter.c filter.h ahrs.c ahrs.h control.c control.h
  group protocol
    ../app/protocol/: usart_report.c usart_report.h rc.c rc.h
  group driver
    ../lib/driver_lib/: driver.c driver.h spi.c spi.h nrf24L01.c nrf24L01.h delay.c delay.h sys.c sys.h usart.c usart.h timer.c timer.h motor.c motor.h
    ../lib/driver_lib/iic/: mpuiic.c mpuiic.h
    ../lib/driver_lib/mpu6050/: mpu6050.c mpu6050.h
    ../lib/driver_lib/mpu6050/eMPL/: inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group app
    ../app/: main.c
    ../: doc.txt
